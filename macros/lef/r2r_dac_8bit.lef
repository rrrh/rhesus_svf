VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO r2r_dac_8bit
  CLASS BLOCK ;
  FOREIGN r2r_dac_8bit ;
  ORIGIN 0.000 0.000 ;
  SIZE 1.000 BY 1.000 ;
END r2r_dac_8bit
END LIBRARY

