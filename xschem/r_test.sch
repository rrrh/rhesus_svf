v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {sg13g2_pr/rhigh.sym} 0 0 0 0 {name=R1
w=0.5e-6
l=0.5e-6
model=rhigh
body=sub!
spiceprefix=X
b=0
m=1
}
C {ipin.sym} 0 -30 0 0 {name=p1 lab=Vin}
C {opin.sym} 0 30 2 0 {name=p2 lab=GND}
